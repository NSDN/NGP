# Keil uVision project Test.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W408AS STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: Test +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: base.c ge.c main.c ae.c key.c
  group Header Group 1
    ./: base.h ge.h reg15.h oledfont.h NyaGame.h ae.h key.h
